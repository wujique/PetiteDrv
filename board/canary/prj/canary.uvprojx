# Keil uVision project canary.uvprojx, settings and files
target canary (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: canary +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\app;..\..\canary;..\..\..\driver;..\..\..\driver\lcd;..\..\..\driver\cdev;..\..\..\mcu\stm32f103;..\..\..\mcu\stm32f103\StLib\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcu\stm32f103\mcu_dev;..\..\..\panel;..\..\..\Petite;..\..\..\Utilities\FreeRTOS\Source\include;..\..\..\Utilities\font;..\..\..\Utilities\tslib;..\usb_msc\inc;..\..\..\mcu\stm32f103\StLib\STM32_USB-FS-Device_Driver\inc;..\..\..\mcu\stm32f103\StLib\core;..\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\canary.sct
  group app
    ../../../app/: app.c
  group panel
    ../../../panel/: audio_sample.c emenu.c emenu_test.c
  group board
    ../: board_sysconf.c main.c stm32f10x_it.c board_test.c board_canary.c
    ../rtos/: port.c
  group driver
    ../../../driver/: dev_buzzer.c dev_keypad.c dev_spiflash.c dev_xpt2046.c dev_touchscreen.c
  group driver/lcd
    ../../../driver/lcd/: dev_IL3820.c dev_IL91874.c dev_ILI9325.c dev_ILI9341.c dev_lcd.c dev_st7735r.c dev_st7789.c dev_str7565.c
  group driver/cdev
    ../../../driver/cdev/: dev_htu21d.c dev_ptHCHO.c
  group Petite
    ../../../Petite/: bus_i2c.c bus_vi2c.c bus_lcd.c bus_spi.c bus_vspi.c alloc.c maths.c vfs.c font_8x16.c font_8x8.c font_6x12.c font.c log.c stimer.c p_list.c
  group mcu
    ../../../mcu/stm32f103/: startup_stm32f10x_hd.s system_stm32f10x.c
    ../../../mcu/stm32f103/StLib/core/: core_cm3.c
  group mcu/dev
    ../../../mcu/stm32f103/mcu_dev/: mcu_uart.c mcu_i2c.c mcu_io.c mcu_spi.c mcu_timer.c mcu_fsmc.c mcu_rtc.c
  group mcu/Periph
    ../../../mcu/stm32f103/StLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Utilities/freertos
    ../../../Utilities/FreeRTOS/Source/: frtos_croutine.c frtos_event_groups.c frtos_list.c frtos_queue.c frtos_stream_buffer.c frtos_tasks.c frtos_timers.c
    ../../../Utilities/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Utilities/tslib
    ../../../Utilities/tslib/tests/: testutils.c ts_calibrate.c
    ../../../Utilities/tslib/: tslib.c
