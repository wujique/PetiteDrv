# Keil uVision project wujique.uvprojx, settings and files
target wujique (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wujique +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  c misc: --locale=english
  c include: ..\..\..\app;..\..\wujique;..\usb\inc;..\eth\inc;..\..\..\driver;..\..\..\driver\lcd;..\..\..\driver\cdev;..\..\..\mcu\stm32407\mcu_dev;..\..\..\mcu\stm32407\StLib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\panel;..\..\..\Petite;..\..\..\components\FatFs;..\eth\inc;..\..\..\components\cmd\ubootcmd;..\..\..\components\littlefs-master;..\usb\inc;..\..\..\mcu\stm32407;..\..\..\driver\camera;..\..\..\mcu\stm32407\StLib\CMSIS\Include;..\..\..\driver\touch;..\..\..\components\FreeRTOS\Source\include;..\..\..\components\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\components\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\driver\touch\rtp\tslib;..\..\..\driver\touch\rtp\tslib\tests;..\..\..\driver\sound;..\..\..\driver\touch;..\..\..\driver\touch\rtp;..\..\..\Petite\bus;..\..\..\components\emenu;..\..\..\components\CmBacktrace\cm_backtrace;..\..\..\components\FlashDB\inc;..\..\..\components\FlashDB\porting;..\..\..\components\littlefs;..\..\..\components\Petitefont;..\mcu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\wujique.sct
  group mcu
    ../mcu/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group mcu/STM32F4xx_StdPeriph_Driver
    ../../../mcu/stm32407/StLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mcu/dev
    ../../../mcu/stm32407/mcu_dev/: mcu_adc.c mcu_can.c mcu_dac.c mcu_dcmi.c mcu_i2c.c mcu_i2s.c mcu_rtc.c mcu_sdio.c mcu_spi.c mcu_timer.c mcu_uart.c stm324xg_eval_fsmc_sram.c mcu_io.c
  group driver
    ../../../driver/: drv_buzzer.c drv_key.c drv_rf24l01.c drv_rs485.c drv_spiflash.c drv_srf05.c drv_tea5767.c drv_touchkey.c stm324xg_eval_sdio_sd.c
  group driver/lcd
    ../../../driver/lcd/: drv_nt35510.c drv_r61408.c drv_IL3820.c drv_IL91874.c drv_ILI9325.c drv_ILI9341.c drv_lcd.c drv_st7735r.c drv_st7789.c drv_str7565.c bus_lcd.c drv_st7796u.c
  group driver/cdev
    ../../../driver/cdev/: drv_htu21d.c drv_ptHCHO.c
  group driver/camera
    ../../../driver/camera/: camera_api.c drv_ov2640.c drv_ov9655.c ov5640.c
  group drv/sound
    ../../../driver/sound/: dacsound.c ES8388.c wm8978.c audio_pipeline.c wm8960.c
  group drv/touch
    ../../../driver/touch/rtp/: xpt2046.c rtp_adc.c
    ../../../driver/touch/rtp/tslib/: tslib.c
    ../../../driver/touch/rtp/tslib/tests/: testutils.c ts_calibrate.c
    ../../../driver/touch/: touch.c
  group Petite
    ../../../Petite/: maths.c vfs.c log.c stimer.c petite.c storage.c partition.c petite_dev.c
    ../../../Petite/mem/: alloc.c p_kfifo.c p_list.c p_malloc.c tlsf.c
  group Petite/bus
    ../../../Petite/bus/: bus_i2c.c bus_spi.c bus_uart.c bus_vi2c.c bus_vspi.c
  group panel
    ../../../panel/: audio_sample.c soundplay.c display.c
  group board
    ../: board_sysconf.c main.c board.c stm32f4xx_it.c sd_fat.c stm32f407_hal_msp.c component_src.c
  group cmbacktrace
    ../../../components/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../../../components/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group cmd
    ../../../components/cmd/: cmd_display.c cmd_port.c cmd_sys.c
    ../../../components/cmd/ubootcmd/: cmd.c cmd_nvedit.c commnad.c console.c env.c uif.c
