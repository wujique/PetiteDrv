# Keil uVision project pochard.uvprojx, settings and files
target wujique (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pochard +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  c misc: --locale=english
  c include: ..\..\..\app;..\usb\inc;..\eth\inc;..\..\..\driver;..\..\..\driver\lcd;..\..\..\driver\sensor;..\..\..\mcu\stm32407\mcu_dev;..\..\..\mcu\stm32407\StLib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\panel;..\..\..\Petite;..\..\..\components\FatFs;..\eth\inc;..\..\..\components\cmd\ubootcmd;..\..\..\components\littlefs-master;..\usb\inc;..\..\..\mcu\stm32407;..\..\..\driver\camera;..\..\..\mcu\stm32407\StLib\CMSIS\Include;..\..\..\driver\touch;..\..\..\components\FreeRTOS\Source\include;..\freertos_port;..\..\..\components\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\driver\touch\rtp\tslib;..\..\..\driver\touch\rtp\tslib\tests;..\..\..\driver\codec;..\..\..\driver\touch;..\..\..\driver\touch\rtp;..\..\..\Petite\bus;..\..\..\components\emenu;..\..\..\components\CmBacktrace\cm_backtrace;..\..\..\components\FlashDB\inc;..\..\..\components\FlashDB\porting;..\..\..\components\littlefs;..\..\..\components\Petitefont;..\mcu;..\..\..\components\lvgl;..\lvgl_porting;..\..\pochard;..\sdio_mmc;..\..\..\components\esp_hosted_fg\host\components\include;..\..\..\components\esp_hosted_fg\host\control_lib\include;..\..\..\components\esp_hosted_fg\host\stm32\app\control;..\..\..\components\esp_hosted_fg\host\stm32\app\data;..\..\..\components\esp_hosted_fg\host\stm32\app;..\..\..\components\esp_hosted_fg\host\stm32\common;..\..\..\components\esp_hosted_fg\host\stm32\driver\netif;..\..\..\components\esp_hosted_fg\host\stm32\driver\network;..\..\..\components\esp_hosted_fg\host\stm32\driver\serial;..\..\..\components\esp_hosted_fg\host\stm32\driver\transport\spi;..\..\..\components\esp_hosted_fg\host\stm32\driver\transport;..\..\..\components\esp_hosted_fg\host\stm32\port\include;..\..\..\components\esp_hosted_fg\host\stm32\port;..\..\..\components\esp_hosted_fg\host\virtual_serial_if\include;..\..\..\components\esp_hosted_fg\common\include;..\..\..\components\esp_hosted_fg\common;..\..\..\components\esp_hosted_fg\common\protobuf-c;..\..\..\components\esp_hosted_fg\host\control_lib\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\pochard.sct
  group mcu
    ../mcu/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group mcu/STM32F4xx_StdPeriph_Driver
    ../../../mcu/stm32407/StLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mcu/dev
    ../../../mcu/stm32407/mcu_dev/: mcu_adc.c mcu_can.c mcu_dac.c mcu_dcmi.c mcu_i2c.c mcu_i2s.c mcu_rtc.c mcu_spi.c mcu_timer.c mcu_uart.c stm324xg_eval_fsmc_sram.c mcu_io.c
  group driver
    ../../../driver/: drv_buzzer.c drv_key.c drv_spiflash.c
  group driver/lcd
    ../../../driver/lcd/: drv_nt35510.c drv_r61408.c drv_IL3820.c drv_IL91874.c drv_ILI9325.c drv_ILI9341.c drv_lcd.c drv_st7735r.c drv_st7789.c drv_str7565.c bus_lcd.c drv_st7796u.c
  group driver/sensor
    ../../../driver/sensor/: drv_htu21d.c drv_ptHCHO.c
  group driver/camera
    ../../../driver/camera/: camera_api.c drv_ov2640.c drv_ov9655.c ov5640.c
  group drv/codec
    ../../../driver/codec/: dacsound.c wm8960.c wm8978.c audio_pipeline.c
  group drv/touch
    ../../../driver/touch/rtp/: xpt2046.c rtp_adc.c
    ../../../driver/touch/rtp/tslib/: tslib.c
    ../../../driver/touch/rtp/tslib/tests/: testutils.c ts_calibrate.c
    ../../../driver/touch/: touch.c
    ../../../driver/touch/ctp/: gt1151.c
  group Petite
    ../../../Petite/: maths.c vfs.c log.c stimer.c petite.c storage.c partition.c petite_dev.c clib.c
    ../../../Petite/mem/: alloc.c p_kfifo.c p_list.c p_malloc.c tlsf.c
  group Petite/bus
    ../../../Petite/bus/: bus_i2c.c bus_spi.c bus_uart.c bus_vi2c.c bus_vspi.c
  group panel
    ../../../panel/: audio_sample.c soundplay.c display.c
  group board
    ../: board_sysconf.c main.c board.c stm32f4xx_it.c sd_fat.c stm32f407_hal_msp.c component_src.c
    ../sdio_mmc/: board_sdio.c stm324xg_eval_sdio_sd.c
  group cmbacktrace
    ../../../components/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../../../components/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group cmd
    ../../../components/cmd/: cmd_display.c cmd_port.c cmd_sys.c
    ../../../components/cmd/ubootcmd/: cmd.c cmd_nvedit.c commnad.c console.c env.c uif.c
  group lvgldemo
    ../../../components/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../components/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../../../components/lvgl/demos/widgets/: lv_demo_widgets.c
    ../../../components/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group lvgl_core
    ../../../components/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../../../components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_gradient.c lv_draw_sw_dither.c
  group lvgl_extra
    ../../../components/lvgl/src/extra/: lv_extra.c
    ../../../components/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../components/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../components/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../components/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../components/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../components/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../components/lvgl/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../../../components/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../components/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../components/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../components/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../components/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../components/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../components/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../components/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../components/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../components/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../components/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../components/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../components/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../components/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../components/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../../../components/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../../../components/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../../../components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../../../components/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group freertos
    ../../../components/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group lv_port
    ../lvgl_porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group esp_host
    ../../../components/esp_hosted_fg/common/protobuf-c/protobuf-c/: protobuf-c.c
    ../../../components/esp_hosted_fg/common/: esp_hosted_config.pb-c.c
    ../../../components/esp_hosted_fg/host/components/src/: esp_queue.c
    ../../../components/esp_hosted_fg/host/control_lib/src/: ctrl_api.c ctrl_core.c
    ../../../components/esp_hosted_fg/host/stm32/app/: app_main.c app_main_api.c
    ../../../components/esp_hosted_fg/host/stm32/common/: common.c stats.c util.c
    ../../../components/esp_hosted_fg/host/stm32/app/control/: control.c control_utils.c
    ../../../components/esp_hosted_fg/host/stm32/app/data/: arp_server_stub.c
    ../../../components/esp_hosted_fg/host/stm32/driver/network/: netdev_api.c netdev_stub.c
    ../../../components/esp_hosted_fg/host/stm32/driver/serial/: serial_ll_if.c
    ../../../components/esp_hosted_fg/host/stm32/driver/transport/spi/: spi_drv.c
    ../../../components/esp_hosted_fg/host/stm32/driver/transport/: transport_drv.c
    ../../../components/esp_hosted_fg/host/stm32/port/src/: platform_wrapper.c
    ../../../components/esp_hosted_fg/host/virtual_serial_if/src/: serial_if.c
