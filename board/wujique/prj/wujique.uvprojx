# Keil uVision project wujique.uvprojx, settings and files
target wujique (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wujique +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\app;..\..\wujique;..\usb\inc;..\eth\inc;..\..\..\driver;..\..\..\driver\lcd;..\..\..\driver\cdev;..\..\..\mcu\stm32407\mcu_dev;..\..\..\mcu\stm32407\StLib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\panel;..\..\..\Petite;..\..\..\Utilities\FreeRTOS\Source\include;..\..\..\Utilities\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\mcu\stm32407\StLib\STM32_USB_OTG_Driver\inc;..\..\..\mcu\stm32407\StLib\STM32_USB_HOST_Library\Core\inc;..\..\..\mcu\stm32407\StLib\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\mcu\stm32407\StLib\STM32_USB_Device_Library\Core\inc;..\..\..\mcu\stm32407\StLib\STM32_USB_Device_Library\Class\msc\inc;..\..\..\Utilities\fat_fs\src;..\eth\inc;..\..\..\mcu\stm32407\StLib\STM32F4x7_ETH_Driver\inc;..\..\..\Utilities\lwip-1.4.1\port\STM32F4x7\Standalone;..\..\..\Utilities\lwip-1.4.1\src\include\ipv4;..\..\..\Utilities\lwip-1.4.1\src\include;..\..\..\Utilities\lwip-1.4.1\src\include\netif;..\..\..\Utilities\lwip-1.4.1\src\include\lwip;..\..\..\Utilities\lwip-1.4.1\port\STM32F4x7;..\..\..\Utilities\tslib;..\..\..\Utilities\cmd;..\..\..\Utilities\spiffs-0.3.7\src;..\..\..\Utilities\littlefs-master;..\usb\inc;..\..\..\mcu\stm32407;..\..\..\Utilities\font;..\..\..\driver\camera;..\..\..\mcu\stm32407\StLib\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\wujique.sct
  group app
    ../../../app/: main.c sys_littlefs.c sys_spiffs.c
  group panel
    ../../../panel/: audio_sample.c emenu.c emenu_test.c soundplay.c
  group driver
    ../../../driver/: dev_buzzer.c dev_dacsound.c dev_esp8266.c dev_key.c dev_keypad.c dev_rf24l01.c dev_rs485.c dev_spiflash.c dev_srf05.c dev_tea5767.c dev_touchkey.c dev_touchscreen.c dev_wm8978.c dev_xpt2046.c stm324xg_eval_sdio_sd.c
  group driver/lcd
    ../../../driver/lcd/: dev_IL3820.c dev_IL91874.c dev_ILI9325.c dev_ILI9341.c dev_lcd.c dev_st7735r.c dev_st7789.c dev_str7565.c
  group driver/cdev
    ../../../driver/cdev/: dev_htu21d.c dev_ptHCHO.c
  group driver/camera
    ../../../driver/camera/: camera_api.c drv_ov2640.c drv_ov9655.c
  group Petite
    ../../../Petite/: bus_i2c.c bus_lcd.c bus_spi.c alloc.c maths.c bus_vi2c.c bus_vspi.c vfs.c font.c font_6x12.c font_8x8.c font_8x16.c log.c stimer.c p_list.c
  group mcu
    ../../../mcu/stm32407/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group mcu/dev
    ../../../mcu/stm32407/mcu_dev/: mcu_adc.c mcu_can.c mcu_dac.c mcu_dcmi.c mcu_i2c.c mcu_i2s.c mcu_rtc.c mcu_sdio.c mcu_spi.c mcu_timer.c mcu_uart.c stm324xg_eval_fsmc_sram.c mcu_io.c
  group mcu/STM32F4xx_StdPeriph_Driver
    ../../../mcu/stm32407/StLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mcu/usb/otg_driver
    ../../../mcu/stm32407/StLib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group mcu/usb/host_core
    ../../../mcu/stm32407/StLib/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group mcu/usb/host_class_msc
    ../../../mcu/stm32407/StLib/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group mcu/usb/device_core
    ../../../mcu/stm32407/StLib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group mcu/usb/device_class_msc
    ../../../mcu/stm32407/StLib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group mcu/STM32F4X7_ETH_Driver
    ../../../mcu/stm32407/StLib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Utilities/lwip
    ../../../Utilities/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Utilities/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../Utilities/lwip-1.4.1/src/netif/: etharp.c
    ../../../Utilities/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
  group Utilities/cmd
    ../../../Utilities/cmd/: cmd.c cmd_nvedit.c cmd_sys.c commnad.c console.c env.c cmd_spiffs.c
  group Utilities/freertos
    ../../../Utilities/FreeRTOS/Source/: frtos_croutine.c frtos_event_groups.c frtos_list.c frtos_queue.c frtos_stream_buffer.c frtos_tasks.c frtos_timers.c
    ../../../Utilities/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Utilities/spiffs
    ../../../Utilities/spiffs-0.3.7/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
  group Utilities/littlefs
    ../../../Utilities/littlefs-master/: lfs_util.c lfs.c
  group Utilities/fatfs
    ../../../Utilities/fat_fs/src/: diskio.c ff.c
    ../../../Utilities/fat_fs/src/option/: cc936.c syscall.c
  group Utilities/tslib
    ../../../Utilities/tslib/tests/: testutils.c ts_calibrate.c
    ../../../Utilities/tslib/: tslib.c
  group board
    ../: board_sysconf.c wujique_main.c wujique_test.c
  group board/eth
    ../eth/src/: eth_app.c netconf.c stm32f4x7_eth_bsp.c tcp_echoserver.c
  group board/usb
    ../usb/src/: dual_func_demo.c usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbh_msc_usr.c
