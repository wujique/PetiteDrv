# Keil uVision project h7b0_mdk_demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h7b0_mdk_demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  c include: .\Core\Inc;.\Drivers\STM32H7xx_HAL_Driver\Inc;.\User;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32H7xx\Include;.\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\mcu\stm32h7b0vb;..\..\Petite;..\..\driver;..\..\driver\touch;..\..\driver\lcd;..\..\Utilities\lvgl;..\..\Utilities\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Utilities\FreeRTOS\Source\include;..\..\Utilities\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\Utilities\FatFs;..\..\driver\sound;..\..\driver\touch\rtp\tslib;..\..\driver\touch\rtp;..\..\Petite\bus
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x200000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\Objects\h7b0_mdk_demo.sct
  group core
    ./Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ./Core/Startup/: startup_stm32h7b0xx.s
  group Drivers
    ./Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group User
    ./User/: cuckoo_test.c board.c board_sysconf.c w25q64.c test_qspi.c sd_fat.c
  group Petite
    ../../Petite/: log.c maths.c petite.c pfsm.c stimer.c vfs.c
    ../../Petite/mem/: p_list.c p_kfifo.c alloc.c
    ../../Petite/font/: font.c font_6x12.c font_8x8.c font_8x16.c font_wjq.c font_ymy.c
    ../../Petite/bus/: bus_i2c.c bus_lcd.c bus_spi.c bus_uart.c bus_vi2c.c bus_vspi.c
  group mcu
    ../../mcu/stm32h7b0vb/: mcu_dcmi.c mcu_io.c mcu_LTDC.c mcu_octospi.c mcu_spi.c mcu_uart.c sdmmc_sd.c mcu_i2s.c mcu_i2c.c mcu_timer.c
  group drv/lcd
    ../../driver/lcd/: drv_st7735r.c drv_st7789.c drv_str7565.c drv_lcd.c drv_IL3820.c
  group drv/touch
    ../../driver/touch/: touch.c
    ../../driver/touch/ctp/: GT9147.c gt1151.c
    ../../driver/touch/rtp/tslib/: tslib.c
    ../../driver/touch/rtp/tslib/tests/: ts_calibrate.c testutils.c
    ../../driver/touch/rtp/: xpt2046.c
  group drv/sound
    ../../driver/sound/: audio_pipeline.c wm8978.c
  group drv/camera
    ../../driver/camera/: camera_api.c drv_ov2640.c ov5640.c
  group panel
    ../../panel/: display.c soundplay.c audio_sample.c
  group mid/freertos
    ../../Utilities/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Utilities/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Utilities/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Utilities/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group mid/lvgl
    ../../Utilities/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../Utilities/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Utilities/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Utilities/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Utilities/lvgl/src/extra/: lv_extra.c
    ../../Utilities/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../../Utilities/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Utilities/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Utilities/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Utilities/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Utilities/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Utilities/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Utilities/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group mid/lvgl/port
    ../../Utilities/lvgl/porting/: lv_port_indev.c lv_port_fs.c lv_port_disp.c
  group mid/lvgl/demo
    ../../Utilities/lvgl/demos/widgets/: lv_demo_widgets.c
    ../../Utilities/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group mid/fatfs
    ../../Utilities/FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c
    ./User/: sd_diskio.c
